# IAR project Key_Exti.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Key_Exti.hex
  ILINK.IlinkOutputFile: Key_Exti.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: clk_conf.c key_exti.c led.c main.c stm8s_interruput.c
