# IAR project Backup of STM8_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_Demo.hex
  ILINK.IlinkOutputFile: STM8_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: clk_conf.c main.c
