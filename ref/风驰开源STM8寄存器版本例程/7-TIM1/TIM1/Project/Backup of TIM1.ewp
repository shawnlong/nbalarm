# IAR project Backup of TIM1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM1.hex
  ILINK.IlinkOutputFile: TIM1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: clk_conf.c led.c main.c stm8s_interruput.c tim1.c
