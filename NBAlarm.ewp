# IAR project NBAlarm.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: NBAlarm.hex
  ILINK.IlinkOutputFile: NBAlarm.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c awu.c battery.c dtu.c gpio.c main.c msg.c sensor.c speaker.c test.c timer.c uart.c
  group h
    ./: adc.h awu.h battery.h dtu.h gpio.h msg.h sensor.h speaker.h test.h timer.h uart.h
