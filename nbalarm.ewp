# IAR project nbalarm.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: lib\inc\; user\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: nbalarm.hex
  ILINK.IlinkOutputFile: nbalarm.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib/inc
    lib/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group lib/src
    lib/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c stm8s_wwdg.c
  group user/inc
    user/inc/: awu.h
    user/: battery.h dtu.h msg.h sensor.h speaker.h stm8s_conf.h stm8s_it.h test.h timer.h uart.h
  group user/src
    user/src/: awu.c battery.c dtu.c main.c msg.c sensor.c speaker.c stm8s_it.c test.c timer.c uart.c
